# Keil uVision project Project.uvprojx, settings and files
target GD32F10X_CL (ARM-ADS)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL
  c include: ..\;..\Firmware\CMSIS\GD\GD32F10x\Include;..\Firmware\CMSIS;..\Utilities\LCD_common;..\Firmware\GD32F10x_standard_peripheral\Include;..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../App_Main/: gd32f10x_it.c main.c
  group CMSIS
    ../Firmware_Lib/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../Firmware_Lib/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../Firmware_Lib/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Utilities
    ../Utilities/: gd32f10x_eval.c
  group Doc
    ../: readme.txt
  group key
    ../Key/: key.c
  group led
    ../Led/: led.c
  group uart
    ../Uart/: uart.c
  group oled
    ../Oled/: oled.c
  group delay
    ../Delay/: delay.c
  group iic
    ../IIC/: iic.c
target GD32F10X_MD (ARM-ADS)
  device: GD32F103VB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_common;..\..\Firmware\GD32F10x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32F10X_HD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TomatoClock
  AfterMake: fromelf.exe --bin --output "./output/TomatoClock.bin" "./output/TomatoClock.axf"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\Firmware_Lib\CMSIS\GD\GD32F10x\Include;..\Firmware_Lib\CMSIS;..\Utilities;..\Utilities\LCD_common;..\Firmware_Lib\GD32F10x_standard_peripheral\Include;..\Key;..\Led;..\Uart;..\Firmware_Lib;..\Oled;..\Delay;..\App_Main;..\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target GD32F10X_XD (ARM-ADS)
  device: GD32F103VK GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00300000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_XD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
